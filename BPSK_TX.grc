options:
  parameters:
    generate_options: qt_gui
    id: BPSK_TX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: BPSK
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: access_code
  id: variable
  parameters:
    value: '''10100001110001001111001011100111'''
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '.35'
  states: {}
- name: hdr_format
  id: variable
  parameters:
    value: digital.header_format_default(access_code, threshold)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 550e3
  states: {}
- name: sps
  id: variable
  parameters:
    value: '8'
  states: {}
- name: threshold
  id: variable
  parameters:
    value: '1'
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 210e3
    low_cutoff_freq: 190e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '.7'
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '60'
    type: byte
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: packet_len
    ninputs: '2'
    type: byte
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: BPSK
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_protocol_formatter_bb_0
  id: digital_protocol_formatter_bb
  parameters:
    format: hdr_format
    len_tag_key: '"packet_len"'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      from gnuradio import gr
      import numpy as np
      import os

      class repeat_packet_file_source(gr.sync_block):
          """
          A block that reads the contents of a file, wraps it with a hardcoded 50-byte ASCII header and footer, 
          and transmits the packet as a stream of bytes, repeated X times.
          """

          def __init__(self, file_path="/home/ubuntu/Documents/Senior Project/Communication Protocol/test.txt", num_repeats=3):
              gr.sync_block.__init__(
                  self,
                  name="Repeat Packet File Source",  # Block name
                  in_sig=None,                       # No input signal
                  out_sig=[np.uint8],                # Output is a stream of bytes
              )

              # Parameters
              self.file_path = file_path
              self.num_repeats = num_repeats

              # Validate and read file
              if not os.path.isfile(self.file_path):
                  raise ValueError(f"File not found: {self.file_path}")
              with open(self.file_path, "rb") as f:
                  self.file_data = f.read()  # Read entire file into memory

              # Hardcoded ASCII header and footer
              self.header = ("A" * 256).encode("ascii")  # 50 bytes of ASCII 'a'
              self.footer = ("A" * 256).encode("ascii")  # 50 bytes of ASCII 'A'

              # Create the packet (header + file_data + footer)
              self.packet = self.header + self.file_data + self.footer

              # Repeat the packet X times
              self.buffer = self.packet * self.num_repeats

          def work(self, input_items, output_items):
              """
              Outputs the packetized data as a byte stream, repeated X times.
              """
              out = output_items[0]

              # If buffer is empty, stop processing
             # if not self.buffer:
                #  return -1

              # Determine how much data to output
              to_write = min(len(self.buffer), len(out))

              # Write data to the output buffer
              out[:to_write] = np.frombuffer(self.buffer[:to_write], dtype=np.uint8)

              # Remove the transmitted portion from the buffer
              self.buffer = self.buffer[to_write:]

              return to_write
    file_path: '"/home/ubuntu/Documents/Senior Project/Communication Protocol/command.txt"'
    num_repeats: '25000'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class preamble_inserter(gr.sync_block):
          def __init__(self, preamble=0xAAAAAAAAAAAAAAAA, pkt_len=64):
              gr.sync_block.__init__(
                  self,
                  name='64-bit Preamble Inserter',
                  in_sig=[np.uint8],
                  out_sig=[np.uint8]
              )
              self.preamble = preamble.to_bytes(8, byteorder='big')
              self.pkt_len = pkt_len
              self.preamble_sent = False
              self.tag_position = 0

          def work(self, input_items, output_items):
              if not self.preamble_sent:
                  # Insert the preamble
                  output_items[0][:8] = np.frombuffer(self.preamble, dtype=np.uint8)
                  self.preamble_sent = True
                  self.tag_position += 8
                  return 8
              
              # Pass the input items after sending the preamble
              output_len = len(input_items[0])
              output_items[0][:output_len] = input_items[0]
              
              # Attach a packet length tag
              tag_key = pmt.intern("packet_len")
              tag_value = pmt.from_long(self.pkt_len)
              self.add_item_tag(0, self.tag_position, tag_key, tag_value)
              self.tag_position += output_len
              
              return output_len
    pkt_len: '64'
    preamble: '0xAAAAAAAAAAAAAAAA'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nimport numpy as np\nimport zmq\nfrom gnuradio import gr\nimport pmt\n\nclass blk(gr.sync_block):  \n    \"\"\"Detect single tone using RMS input; output via ZMQ, PMT, and GNU Radio stream\"\"\"\n\n    def __init__(self, threshold=0.1, zmq_port=7040):  \n        gr.sync_block.__init__(\n            self,\n            name='detect_single_tone',  \n            in_sig=[np.float32],  # Only one RMS input now\n            out_sig=[np.float32]  # Single output (binary detection result)\n        )\n        self.threshold = threshold\n        self.last_sent = None\n\n        # ZMQ PUB setup\n        self.context = zmq.Context()\n        self.socket = self.context.socket(zmq.PUB)\n        self.socket.bind(f\"tcp://*:{zmq_port}\")\n\n        # PMT output port\n        self.message_port_register_out(pmt.intern(\"detected_flag\"))\n\n    def work(self, input_items, output_items):\n        \"\"\"Check if tone is present and send detection status\"\"\"\n        rms = input_items[0]\n        out = output_items[0]\n\n        tone_value = 1 if np.mean(rms) > self.threshold else 0\n\n        if tone_value != self.last_sent:\n            self.socket.send_string(str(tone_value))\n            self.last_sent = tone_value\n\n        self.message_port_pub(pmt.intern(\"detected_flag\"), pmt.from_long(tone_value))\n        out[:] = float(tone_value)\n\n        return len(output_items[0])\n\n"
    threshold: '.01'
    zmq_port: '4010'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 5e6
    center_freq: 433e6
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 5e6
    center_freq: 445e6
    gain: '30.0'
    samp_rate: samp_rate
    type: fc32
  states: {}

connections:
- [band_pass_filter_1, '0', blocks_rms_xx_0, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_rms_xx_0, '0', epy_block_0_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', epy_block_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_constellation_modulator_0, '0']
- [digital_constellation_modulator_0, '0', blocks_multiply_const_vxx_0, '0']
- [digital_protocol_formatter_bb_0, '0', blocks_tagged_stream_mux_0, '0']
- [epy_block_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [epy_block_0_0, '0', blocks_tagged_stream_mux_0, '1']
- [epy_block_0_0, '0', digital_protocol_formatter_bb_0, '0']
- [epy_block_0_0_0, '0', qtgui_number_sink_2, '0']
- [soapy_limesdr_source_0, '0', band_pass_filter_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
