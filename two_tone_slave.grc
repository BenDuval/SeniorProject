options:
  parameters:
    generate_options: qt_gui
    id: two_tone_slave
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.1e6
    low_cutoff_freq: 0.9e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.1e6
    low_cutoff_freq: 1.9e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_1
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import zmq
      from gnuradio import gr

      class blk(gr.sync_block):  
          """Embedded Python Block for detecting two specific tones, with ZMQ output"""

          def __init__(self, threshold=0.1, zmq_port=7040):  
              gr.sync_block.__init__(
                  self,
                  name='detect_two_tone',  
                  in_sig=[np.float32, np.float32],  # Two input signals (RMS values)
                  out_sig=[np.float32]  # Single output (binary detection result)
              )
              self.threshold = threshold
              self.last_sent = None  # Track last sent value to avoid redundant messages

              # Set up ZMQ PUB socket
              self.context = zmq.Context()
              self.socket = self.context.socket(zmq.PUB)
              self.socket.bind(f"tcp://*:{zmq_port}")

          def work(self, input_items, output_items):
              """Check if both tones are present and send ZMQ messages if detected"""
              rms_430 = input_items[0]  # RMS of first frequency
              rms_435 = input_items[1]  # RMS of second frequency
              out = output_items[0]

              # Check if the RMS values exceed the threshold
              if np.mean(rms_430) > self.threshold and np.mean(rms_435) > self.threshold:
                  tone_value = 1  # Detected the correct combination
              else:
                  tone_value = 0  # No detection

              # Send ZMQ message **only if the value has changed** to avoid unnecessary messages
              if tone_value != self.last_sent:
                  self.socket.send_string(str(tone_value))  # Send updated detection status over ZMQ
                  self.last_sent = tone_value  # Update last sent value

              # Pass the value to the GNU Radio output
              out[:] = float(tone_value)

              return len(output_items[0])
    threshold: '.01'
    zmq_port: '8040'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    type: complex
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    center_freq: 440e6
    gain: '40.0'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: 6e6
    center_freq: 430e6
    gain: '40'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:5020"'
    hwm: '0'
    timeout: '100'
    type: complex
  states: {}

connections:
- [band_pass_filter_0, '0', blocks_rms_xx_1, '0']
- [band_pass_filter_0, '0', qtgui_freq_sink_x_0_1, '0']
- [band_pass_filter_1, '0', blocks_rms_xx_0, '0']
- [band_pass_filter_1, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_rms_xx_0, '0', epy_block_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_1, '0', epy_block_0, '1']
- [blocks_rms_xx_1, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', qtgui_number_sink_2, '0']
- [soapy_limesdr_source_0, '0', band_pass_filter_0, '0']
- [soapy_limesdr_source_0, '0', band_pass_filter_1, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', soapy_limesdr_sink_0, '0']
- [soapy_limesdr_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
