options:
  parameters:
    generate_options: qt_gui
    id: TwoToneTransciever
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: decimation
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: tone
  id: variable
  parameters:
    value: '0'
  states: {}
- name: transition_bw
  id: variable
  parameters:
    value: 30e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: 1e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: '10'
    freq: 2e6
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 1.1e6
    low_cutoff_freq: 900e3
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.1e6
    low_cutoff_freq: 1.9e6
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: '1000'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: blocks_rms_xx_0_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.0001'
    type: complex
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  
          """Custom Block to multiply complex signal source by a message-controlled value"""

          def __init__(self, default_value=1.0):  
              gr.sync_block.__init__(
                  self,
                  name='amplitude_control_complex',  
                  in_sig=[np.complex64],  # Complex input
                  out_sig=[np.complex64]  # Complex output
              )
              self.amplitude = default_value  # Default amplitude ON (1.0)
              self.amplitude_locked = False  # Track if amplitude has been turned off

              self.message_port_register_in(pmt.intern("in"))  # Register message input
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)  # Set handler for incoming messages

          def handle_msg(self, msg):
              """Handle incoming messages to update amplitude"""
              if pmt.is_integer(msg) or pmt.is_real(msg):  # Ensure the message is numeric
                  flag = pmt.to_long(msg)  # Convert PMT message to integer
                  if flag == 1 and not self.amplitude_locked:
                      self.amplitude = 0.0  # Turn OFF amplitude when dual tone detected
                      self.amplitude_locked = True  # Lock the state to OFF

          def work(self, input_items, output_items):
              """Multiply the complex input signal by the amplitude"""
              signal = input_items[0]
              output_items[0][:] = self.amplitude * signal  # Apply amplitude to the complex signal

              return len(output_items[0])
    default_value: '1.0'
  states: {}
- name: epy_block_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):  
          """Custom Block to multiply complex signal source by a message-controlled value"""

          def __init__(self, default_value=1.0):  
              gr.sync_block.__init__(
                  self,
                  name='amplitude_control_complex',  
                  in_sig=[np.complex64],  # Complex input
                  out_sig=[np.complex64]  # Complex output
              )
              self.amplitude = default_value  # Default amplitude ON (1.0)
              self.amplitude_locked = False  # Track if amplitude has been turned off

              self.message_port_register_in(pmt.intern("in"))  # Register message input
              self.set_msg_handler(pmt.intern("in"), self.handle_msg)  # Set handler for incoming messages

          def handle_msg(self, msg):
              """Handle incoming messages to update amplitude"""
              if pmt.is_integer(msg) or pmt.is_real(msg):  # Ensure the message is numeric
                  flag = pmt.to_long(msg)  # Convert PMT message to integer
                  if flag == 1 and not self.amplitude_locked:
                      self.amplitude = 0.0  # Turn OFF amplitude when dual tone detected
                      self.amplitude_locked = True  # Lock the state to OFF

          def work(self, input_items, output_items):
              """Multiply the complex input signal by the amplitude"""
              signal = input_items[0]
              output_items[0][:] = self.amplitude * signal  # Apply amplitude to the complex signal

              return len(output_items[0])
    default_value: '1.0'
  states: {}
- name: epy_block_0_0_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      import zmq
      from gnuradio import gr
      import pmt  # Import PMT for message passing

      class blk(gr.sync_block):  
          """Embedded Python Block for detecting two specific tones, with ZMQ and PMT output"""

          def __init__(self, threshold=0.1, zmq_port=7040):  
              gr.sync_block.__init__(
                  self,
                  name='detect_two_tone',  
                  in_sig=[np.float32, np.float32],  # Two input signals (RMS values)
                  out_sig=[np.float32]  # Single output (binary detection result)
              )
              self.threshold = threshold
              self.last_sent = None  # Track last sent value to avoid redundant messages

              # Set up ZMQ PUB socket
              self.context = zmq.Context()
              self.socket = self.context.socket(zmq.PUB)
              self.socket.bind(f"tcp://*:{zmq_port}")

              # Register PMT message output
              self.message_port_register_out(pmt.intern("detected_flag"))

          def work(self, input_items, output_items):
              """Check if both tones are present and send ZMQ + PMT messages if detected"""
              rms_430 = input_items[0]  # RMS of first frequency
              rms_435 = input_items[1]  # RMS of second frequency
              out = output_items[0]

              # Check if the RMS values exceed the threshold
              if np.mean(rms_430) > self.threshold and np.mean(rms_435) > self.threshold:
                  tone_value = 1  # Detected the correct combination
              else:
                  tone_value = 0  # No detection

              # Send ZMQ message **only if the value has changed** to avoid unnecessary messages
              if tone_value != self.last_sent:
                  self.socket.send_string(str(tone_value))  # Send updated detection status over ZMQ
                  self.last_sent = tone_value  # Update last sent value

              # Send PMT message
              self.message_port_pub(pmt.intern("detected_flag"), pmt.from_long(tone_value))

              # Pass the value to the GNU Radio output
              out[:] = float(tone_value)

              return len(output_items[0])
    threshold: '.01'
    zmq_port: '8040'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"1MHz"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_1
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"2MHz"'
    type: float
  states: {state: disabled}
- name: qtgui_number_sink_2
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    name: '"DetectTwoTone"'
    type: float
  states: {}
- name: soapy_limesdr_sink_0
  id: soapy_limesdr_sink
  parameters:
    bandwidth: 5e6
    center_freq: 435e6
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: soapy_limesdr_source_0
  id: soapy_limesdr_source
  parameters:
    bandwidth: '0'
    center_freq: 440e6
    gain: '30'
    samp_rate: samp_rate
    type: fc32
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: '"tcp://*:5020"'
    hwm: '0'
    timeout: '100'
    type: complex
  states: {}

connections:
- [analog_sig_source_x_0, '0', epy_block_0, '0']
- [analog_sig_source_x_0_0, '0', epy_block_0_0, '0']
- [band_pass_filter_0, '0', blocks_rms_xx_0, '0']
- [band_pass_filter_1, '0', blocks_rms_xx_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_add_xx_0, '0', soapy_limesdr_sink_0, '0']
- [blocks_rms_xx_0, '0', epy_block_0_0_0, '0']
- [blocks_rms_xx_0, '0', qtgui_number_sink_0, '0']
- [blocks_rms_xx_0_0, '0', epy_block_0_0_0, '1']
- [blocks_rms_xx_0_0, '0', qtgui_number_sink_1, '0']
- [epy_block_0, '0', blocks_add_xx_0, '0']
- [epy_block_0_0, '0', blocks_add_xx_0, '1']
- [epy_block_0_0_0, '0', qtgui_number_sink_2, '0']
- [epy_block_0_0_0, detected_flag, epy_block_0, in]
- [epy_block_0_0_0, detected_flag, epy_block_0_0, in]
- [soapy_limesdr_source_0, '0', band_pass_filter_0, '0']
- [soapy_limesdr_source_0, '0', band_pass_filter_1, '0']
- [soapy_limesdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_limesdr_source_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.11.0
